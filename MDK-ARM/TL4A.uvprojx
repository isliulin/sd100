# Keil uVision project TL4A.uvprojx, settings and files
target TL4A (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: sl600e +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L476xx,USE_HAL_DRIVER
  c include: ../Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;..\uCOSIII\APP;..\BSP;..\uCOSIII\uC-CPU;..\uCOSIII\uC-CPU\ARM-Cortex-M3\RealView;..\uCOSIII\uC-LIB;..\uCOSIII\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\uCOSIII\uCOS-III\Ports;..\uCOSIII\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\uCOSIII\uCOS-III\Source;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;..\user;..\NW;..\Middlewares\Third_Party\LwIP\system;..\Middlewares\Third_Party\LwIP\src\include\lwip;..\Middlewares\Third_Party\LwIP\src\include\netif;..\Middlewares\Third_Party\LwIP\src\include\posix;..\Middlewares\Third_Party\LwIP\src\include;..\LwIP_user;..\HK_user;..\Middlewares\Third_Party\FatFs\src;..\work;..\sys_user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group NW
    ../Doc/: 备注事宜.txt
    ../NW/: NW_Task.c nw_api.c nw.h Rev4g_polling.c Contact_polling.c Sdata_polling.c global.h
  group uC/APP
    ../uCOSIII/APP/: app.c app_cfg.h includes.h os_app_hooks.c os_app_hooks.h
  group Application/User
    ../Src/: main.c gpio.c i2c.c iwdg.c rtc.c spi.c usart.c stm32l4xx_it.c stm32l4xx_hal_msp.c dma.c fft_syf.c tim.c
    ../Inc/: mydefine.h fft_syf.h
  group IC_driver
    ../IC_driver/: MX35.c MX35.h sim7600.c sim7600.h LEA_M8T.c LEA_M8T.h AD7685.c AD7685.h AD5620.c AD5620.h ADS1110.c ADS1110.h ADE7880.c ADE7880.h MX35_0.c MX35_1.c MX35_0 - 副本 (3).c MX35_0 - 副本.c
  group BSP
    ../BSP/: bsp.c dm9k_rt_print.c FM25V10.c FM25V10.h stm32l4xx_hal_uart_s.c bsp_uart.c bsp_uart.h bsp.h data_change.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_ll_fmc.c stm32l4xx_hal_sram.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_ll_sdmmc.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_timebase_tim_template.c
  group DOC
    ../Doc/: FatFs.txt readme.txt STM32固件库文件分析.txt UCOS常用API.txt 功能图.txt 字符处理.txt
  group sys_usr
    ../sys_user/: sys_user.c sys_user.h power_ctrl.c power_ctrl.h
  group g_data
    ../NW/: Gdate_Task.c ALL_data.c
  group Work
    ../NW/: WR_Task.c
  group uC/CPU
    ../uCOSIII/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../uCOSIII/uC-CPU/ARM-Cortex-M3/RealView/: cpu.h cpu_a.asm cpu_c.c
  group uC/LIB
    ../uCOSIII/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../uCOSIII/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group uC/OS-III Port
    ../uCOSIII/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group uC/OS-III Source
    ../uCOSIII/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
    ../Drivers/: startup_stm32l476xxO.s
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
software components: CMSIS:CORE 5.1.1
